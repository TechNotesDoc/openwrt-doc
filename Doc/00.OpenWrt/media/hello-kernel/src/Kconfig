## Doc/00.OpenWrt/media/hello-kernel/src/Kconfig
```kconfig
config HELLO_KERNEL
    tristate "Test kernel driver"
    help
        This is an Kernel Driver Test
```
